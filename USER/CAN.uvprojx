# Keil uVision project CAN.uvprojx, settings and files
target CAN (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CANopenmy +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\CanFestival-3\include;..\HARDWARE\CanFestival-3\include\STM32;..\HARDWARE\CANOpenMaster;..\HARDWARE\Trace;..\FWLIB\inc;..\HARDWARE\MOTOR;..\HARDWARE\PS2;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\RS485;..\HARDWARE\BMS;..\HARDWARE\Infrared
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c GlobalVar.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CanFestival-3/drivers/STM32/: can_stm32.c timer_stm32.c
    ../HARDWARE/MOTOR/: motor_control.c
    ../HARDWARE/PS2/: ps2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/BMS/: bms.c
    ../HARDWARE/Infrared/: infrared.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_adc.c
  group README
    ../: readme.txt
  group can_festival
    ../HARDWARE/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../HARDWARE/CanFestival-3/objdict/: ObjDict.c
    ../HARDWARE/CANOpenMaster/: CANOpenObjDictConfig.c
    ../HARDWARE/Trace/: SEGGER_RTT.c SEGGER_RTT_printf.c
